# PAC URLs need both downloading and JavaScript evaluation, not just storage.
PACKAGECONFIG:append = " curl pacrunner-duktape"
