# Build-time filter generator used by VS Code's bundled sandbox source.
BBCLASSEXTEND += "native"
REQUIRED_DISTRO_FEATURES:class-native = ""
