PACKAGECONFIG:append = " gtk pulseaudio v4l2 jpeg"
